options:
  parameters:
    author: eleonora
    generate_options: qt_gui
    id: client_py3
    output_language: python
    title: client_py3
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '''192.168.122.228'''
  states: {}
- name: base_freq
  id: variable
  parameters:
    value: '101500000'
  states: {}
- name: port
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: address
    port: port
    server: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: base_freq
    fftsize: '1024'
    name: '"SDR"'
    type: complex
  states: {}

connections:
- [network_tcp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
