options:
  parameters:
    author: eleonora
    generate_options: qt_gui
    id: server_py3
    output_language: python
    title: server
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '''RX'''
  states: {}
- name: arguments
  id: variable
  parameters:
    value: ''''''
  states: {}
- name: base_freq
  id: variable
  parameters:
    value: '101500000'
  states: {}
- name: channel
  id: variable
  parameters:
    value: '1'
  states: {}
- name: driver
  id: variable
  parameters:
    value: '''sdrplay'''
  states: {}
- name: port
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 192.168.122.230
    mode: '2'
    port: port
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: base_freq
    driver: driver
    nchan: channel
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_custom_source_0, '0', network_tcp_sink_0, '0']

metadata:
  file_format: 1
